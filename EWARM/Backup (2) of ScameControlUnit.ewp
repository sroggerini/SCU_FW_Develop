# IAR project Backup (2) of ScameControlUnit.ewp, settings and files
configuration FULL_DEBUG_GD32F4xx (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xG GigaDevice GD32F470xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx; PWM_ACTIVE; RFID_PWR_AS_LOW_PWR; CLIENTS_2; V230_MON_ACTIVE; FULL_DEBUG; GD32F4xx; USE_SLEEP_MODE_WHEN_VOLTAGE_IS_ABSENT; no_NO_BOOT; HTS_IMQ; no_NTC_GAIN_1P5; NTC_GAIN_6; MODBUS_TCP_EM_LOVATO; DEBUG_TRACE_PIN; BOARD_REPAIR
  ICCARM.CCDiagSuppress: PA149
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Inc\LIB\uartDbg; ..\Inc\protocol; ..\Inc\Device; ..\Inc\coreApp; ..\Inc\LIB\BSP; ..\Inc\LIB\ftp; ..\Inc\stationMng; ..\Inc\LIB\uartEm; ..\Inc\LIB\rfid; ..\webserver; ..\webserver\httpd; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Inc\protocol\modbus; ..\Inc\protocol\wifi; ..\Inc\protocol; ..\Middlewares\ST\STM32_Cryptographic\include; ..\ISO15118\Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: ScameSCU.bin
  ILINK.IlinkOutputFile: SCU.out
  ILINK.IlinkIcfFile: SCU_GD32F470xG_boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FULL_DEBUG_HW_MP28947_GD32F4xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx; PWM_ACTIVE; RFID_PWR_AS_LOW_PWR; CLIENTS_2; V230_MON_ACTIVE; FULL_DEBUG; GD32F4xx; DEBUG_TRACE_PIN; USE_SLEEP_MODE_WHEN_VOLTAGE_IS_ABSENT; no_NO_BOOT; HTS_IMQ; NTC_GAIN_1P5; no_NTC_GAIN_6; HW_MP28947; SPI_XFER_STPM3X; V230_MON_ACTIVE
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Inc\LIB\uartDbg; ..\Inc\protocol; ..\Inc\Device; ..\Inc\coreApp; ..\Inc\LIB\BSP; ..\Inc\LIB\ftp; ..\Inc\stationMng; ..\Inc\LIB\uartEm; ..\Inc\LIB\rfid; ..\webserver; ..\webserver\httpd; ..\Middlewares\BlueNRG-MS\includes; ..\Middlewares\BlueNRG-MS\utils; ..\Middlewares\BlueNRG-MS\hci\hci_tl_patterns\Basic; ..\Src\BlueTooth\Target; ..\Src\BlueTooth\Application; ..\Src\BlueTooth\Core\Inc; ..\Src\BlueTooth\BSP\Nucleo; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Metrology\drivers\inc; ..\Metrology\handlers\inc; ..\Metrology\include\inc; ..\Metrology\tasks\inc; ..\Inc\protocol\modbus; ..\Inc\protocol\wifi; ..\Inc\protocol; ..\Middlewares\ST\STM32_Cryptographic\include
  ILINK.IlinkOutputFile: SCU-HW_MP28947-GD32.out
configuration FULL_DEBUG_HW_MP28947_STM32H5xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H573VI ST STM32H573VI
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H573xx; PWM_ACTIVE; RFID_PWR_AS_LOW_PWR; CLIENTS_2; FULL_DEBUG; DEBUG_TRACE_PIN; USE_SLEEP_MODE_WHEN_VOLTAGE_IS_ABSENT; no_NO_BOOT; HTS_IMQ; NTC_GAIN_1P5; no_NTC_GAIN_6; HW_MP28947; SPI_XFER_STPM3X; V230_MON_ACTIVE
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Inc\LIB\uartDbg; ..\Inc\protocol; ..\Inc\Device; ..\Inc\coreApp; ..\Inc\LIB\BSP; ..\Inc\LIB\ftp; ..\Inc\stationMng; ..\Inc\LIB\uartEm; ..\Inc\LIB\rfid; ..\webserver; ..\webserver\httpd; ..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\Drivers\STM32H5xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\Metrology\drivers\inc; ..\Metrology\handlers\inc; ..\Metrology\include\inc; ..\Metrology\tasks\inc; ..\Inc\protocol\modbus; ..\Inc\protocol\wifi; ..\Inc\protocol
  ILINK.IlinkOutputFile: SCU-HW_MP28947-H5.out
  ILINK.IlinkIcfFile: stm32h573xx_flash.icf
configuration TARGET_GD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx; PWM_ACTIVE; RFID_PWR_AS_LOW_PWR; CLIENTS_2; V230_MON_ACTIVE; GD32F4xx; DEBUG_TRACE_PIN; USE_SLEEP_MODE_WHEN_VOLTAGE_IS_ABSENT; HTS_IMQ; no_NTC_GAIN_1P5; NTC_GAIN_6; MODBUS_TCP_EM_LOVATO
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Inc\LIB\uartDbg; ..\Inc\protocol; ..\Inc\Device; ..\Inc\coreApp; ..\Inc\LIB\BSP; ..\Inc\LIB\ftp; ..\Inc\stationMng; ..\Inc\LIB\uartEm; ..\Inc\LIB\rfid; ..\webserver; ..\webserver\httpd; ..\Middlewares\BlueNRG-MS\includes; ..\Middlewares\BlueNRG-MS\utils; ..\Middlewares\BlueNRG-MS\hci\hci_tl_patterns\Basic; ..\Src\BlueTooth\Target; ..\Src\BlueTooth\Application; ..\Src\BlueTooth\Core\Inc; ..\Src\BlueTooth\BSP\Nucleo; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Inc\protocol\modbus; ..\Inc\protocol\wifi; ..\Middlewares\ST\STM32_Cryptographic\include; ..\ISO15118\Driver\inc
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SCU_GDF4xx.bin
configuration TARGET_DBG_GD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: as above
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SCU_GDF4xx.bin
configuration TARGET_REL_GD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: as above
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SCU_GDF4xx.bin
configuration TARGET_DBG_HW_MP28947 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx; PWM_ACTIVE; RFID_PWR_AS_LOW_PWR; CLIENTS_2; V230_MON_ACTIVE; GD32F4xx; DEBUG_TRACE_PIN; USE_SLEEP_MODE_WHEN_VOLTAGE_IS_ABSENT; HTS_IMQ; no_NTC_GAIN_1P5; NTC_GAIN_6; HW_MP28947; SPI_XFER_STPM3X; MODBUS_TCP_EM_LOVATO
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Metrology\drivers\inc; ..\Metrology\handlers\inc; ..\Metrology\include\inc; ..\Metrology\tasks\inc; ..\Inc\LIB\uartDbg; ..\Inc\protocol; ..\Inc\Device; ..\Inc\coreApp; ..\Inc\LIB\BSP; ..\Inc\LIB\ftp; ..\Inc\stationMng; ..\Inc\LIB\uartEm; ..\Inc\LIB\rfid; ..\webserver; ..\webserver\httpd; ..\Middlewares\BlueNRG-MS\includes; ..\Middlewares\BlueNRG-MS\utils; ..\Middlewares\BlueNRG-MS\hci\hci_tl_patterns\Basic; ..\Src\BlueTooth\Target; ..\Src\BlueTooth\Application; ..\Src\BlueTooth\Core\Inc; ..\Src\BlueTooth\BSP\Nucleo; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Inc\protocol\modbus; ..\Inc\protocol\wifi; ..\Middlewares\ST\STM32_Cryptographic\include
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SCU_GDF4xx_HW_MP28947.bin
  ILINK.IlinkOutputFile: SCU_GDF4xx_HW_MP28947.out
configuration TARGET_REL_HW_MP28947 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xG GD GD32F470xG
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Inc\LIB\uartDbg; ..\Inc\protocol; ..\Inc\Device; ..\Inc\coreApp; ..\Inc\LIB\BSP; ..\Inc\LIB\ftp; ..\Inc\stationMng; ..\Inc\LIB\uartEm; ..\Inc\LIB\rfid; ..\webserver; ..\webserver\httpd; ..\Middlewares\BlueNRG-MS\includes; ..\Middlewares\BlueNRG-MS\utils; ..\Middlewares\BlueNRG-MS\hci\hci_tl_patterns\Basic; ..\Src\BlueTooth\Target; ..\Src\BlueTooth\Application; ..\Src\BlueTooth\Core\Inc; ..\Src\BlueTooth\BSP\Nucleo; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Metrology\drivers\inc; ..\Metrology\handlers\inc; ..\Metrology\include\inc; ..\Metrology\tasks\inc; ..\Inc\protocol\modbus; ..\Inc\protocol\wifi; ..\Middlewares\ST\STM32_Cryptographic\include
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SCU_GDF4xx_HW_MP28947.bin
  ILINK.IlinkOutputFile: SCU_HW_MP28947.out
  group Application/BSP
    ../Src/LIB/BSP/: eeprom.c hts.c lcd.c rtcApi.c secure_area.c wrapper.c
  group Application/coreApp
    ../Src/coreApp/: adcTask.c ethInitTask.c inputsMng.c ioExp.c ledMng.c monitorMng.c snapsi.c
  group Application/EWARM
    ./: startup_stm32f427xx.s startup_stm32h573xx.s
  group Application/LIB_EM
    ../Src/LIB/EM/: Em_Task.c Em_Uart.c
  group Application/LIB_EM/Metrology/drivers
    ../Metrology/drivers/src/: metrology.c metrology_hal.c metrology_usart.c
  group Application/LIB_EM/Metrology/handlers
    ../Metrology/handlers/src/: handler_metrology.c handler_nvram.c
  group Application/LIB_EM/Metrology/tasks
    ../Metrology/tasks/src/: metroTask.c
  group Application/LIB_FTP
    ../Src/LIB/ftp/: ftps.c ftpserver.c lwftp.c
  group Application/LIB_UART_DBG
    ../Src/LIB/uartDBG/: DataLink_dbg.c dbg_Task.c uartDbg.c
  group Application/Protocol
    ../Src/Protocol/: prot_OnUsart.c sbcGsy.c sbcSem.c sbcUart.c scheduleMng.c scuMdb.c
    ../Src/telnet/: telnet.c
  group Application/Protocol/app
    ../Src/Protocol/: app_emob.c transaction_register.c
  group Application/Protocol/app/modbus
    ../Src/Protocol/modbus/: modbus.c modbus_tcp.c
  group Application/Protocol/app/wifi
    ../Src/Protocol/wifi/: esp32.c stream.c usart_esp32.c wifi.c wifi_esp32.c
  group Application/stationMng
    ../Src/stationMng/: AutotestMng.c BlockMng.c ContactMng.c diffRiarm.c EnergyMng.c EvsMng.c EvsTimeMng.c ExtInpMng.c LcdMng.c PersMng.c PilotMng.c PwmMng.c RfidMng.c
    ../Src/: Event_log.c
  group Application/User
    ../Src/: cmox_low_level.c crc.c ethernetif_stm32f4.c ethernetif_stm32h5.c flash_if.c freertos.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_msp_MP28947.c stm32f4xx_it.c stm32f4xx_periph_init.c stm32f4xx_periph_init_MP28947.c stm32h5xx_hal_msp.c stm32h5xx_it.c stm32h5xx_periph_init.c
  group Device
    ../Src/Device/: ExtFlash_stm32f4.c ExtFlash_stm32h5.c i2c.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c system_stm32h5xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_eth.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_xspi.c
  group ISO15118/Driver/inc
    ../ISO15118/Driver/inc/: homeplugdev.h homeplugdev_spi.h spi_drv.h
  group ISO15118/Driver/src
    ../ISO15118/Driver/src/: homeplugdev.c homeplugdev_spi.c spi_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/STM32Cryptographic
    ../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group Utilities
    ../Src/utilities/: fwChecksum.c
  group webServer
    ../webserver/: configurator.c httpserver-socket.c TCP_socket.c
    ../webserver/httpd/: fs.c
